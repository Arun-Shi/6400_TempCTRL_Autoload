# Keil uVision project stm32.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,__TIM_ALL_INIT,STM32F10X_HD
  c misc: --diag_suppress=188
  c include: .\Hardware;.\Library;.\Start;.\System;.\User;..\Include;.\Freertos\Include;.\Freertos\Portable
  memory RVCT4: ROM 0x8000000 size 0x7f800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c stm32f10x_it.c stm32f10x_conf.h
    ./Freertos/Include/: FreeRTOSConfig.h
  group Library
    ./Library/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_exti.c
  group System
    ./System/delay/: delay.c
    ./System/usart/: usart.c
  group Hardware
    ./Hardware/Smp_IO/: Smp_IO.c
    ./Hardware/Main_Func/: Main_Func.c
    ./Hardware/Command/: Command.c
    ./Hardware/BSP_IIC/: IIC.c
    ./Hardware/M24Cxx/: M24Cxx.c
    ./Freertos/Source/: RTOS_Task.c
    ./Hardware/Fans/: Fans.c
    ./Hardware/PID/: PID.c
    ./Hardware/PWM/: PWM.c
    ./Hardware/TIMER/: timer.c
    ./Hardware/DS18B20/: DS18B20.c
    ./Hardware/ParamSave/: ParamSave.c
  group FreeRTOS_Src
    ./Freertos/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_Port
    ./Freertos/Portable/: heap_4.c port.c
